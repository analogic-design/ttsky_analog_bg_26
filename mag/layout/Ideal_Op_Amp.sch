** sch_path: mag/layout/Ideal_Op_Amp.sch
**.subckt Ideal_Op_Amp V_P V_N V_O
*.ipin V_P
*.ipin V_N
*.opin V_O
G1 V_O 0 V_P V_N 1e6
R3 V_O 0 1 m=1
**.ends
.end
