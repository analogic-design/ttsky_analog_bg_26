** sch_path: mag/untitled.sch
**.subckt untitled
G1 net2 0 0 net3 1e6
R1 net1 net3 1k m=1
R2 net3 net2 2k m=1
R3 net2 0 1 m=1
V1 net1 0 1
**.ends
.end
